<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>key</value></param>
<param><key>value</key><value>crypto.key.make_rand_key(32)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>100000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>1600</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>crypto_sym_ciph_desc</key>
<param><key>id</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>ciph_name</key><value>"aes-256-ctr"</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>key</key><value>key</value></param>
</block>
<block>
<key>crypto_sym_ciph_desc</key>
<param><key>id</key><value>crypto_sym_ciph_desc_1</value></param>
<param><key>ciph_name</key><value>"aes-256-ctr"</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>key</key><value>key</value></param>
</block>
<block>
<key>crypto_sym_dec_tagged_bb</key>
<param><key>id</key><value>crypto_sym_dec_tagged_bb_0</value></param>
<param><key>cipher</key><value>crypto_sym_ciph_desc_1</value></param>
<param><key>packet_key_len</key><value>packet_len</value></param>
</block>
<block>
<key>crypto_sym_enc_tagged_bb</key>
<param><key>id</key><value>crypto_sym_enc_tagged_bb_0</value></param>
<param><key>cipher</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>key_len</key><value>"packet_len"</value></param>
</block>
<block>
<key>fec_ber_bf</key>
<param><key>id</key><value>fec_ber_bf_0</value></param>
<param><key>test_mode</key><value>False</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>0</value></param>
<param><key>min</key><value>-7</value></param>
<param><key>name</key><value>"BER"</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>crypto_sym_enc_tagged_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>fec_ber_bf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_dec_tagged_bb_0</source_block_id><sink_block_id>fec_ber_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_tagged_bb_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_tagged_bb_0</source_block_id><sink_block_id>crypto_sym_dec_tagged_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_ber_bf_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_ber_bf_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
