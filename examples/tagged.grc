<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>127</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/maier/deletememessage</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>16</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>filter</key><value>"new_iv"</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>key</key><value>pmt.intern("new_iv")</value></param>
<param><key>nsamps</key><value>16000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>value</key><value>pmt.intern("")</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(65,)</value></param>
</block>
<block>
<key>crypto_generate_key_pass</key>
<param><key>id</key><value>crypto_generate_key_pass_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>keyfilename</key><value>/home/maier/meinkey.bin</value></param>
<param><key>keylen</key><value>32</value></param>
<param><key>pass</key><value>bier</value></param>
</block>
<block>
<key>crypto_sym_ciph_desc</key>
<param><key>id</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>ciph_name</key><value>"aes-256-ecb"</value></param>
<param><key>keyfile</key><value>/home/maier/meinkey.bin</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>random_iv</key><value>True</value></param>
<param><key>start_iv</key><value>[]</value></param>
</block>
<block>
<key>crypto_sym_dec_tagged_bb</key>
<param><key>id</key><value>crypto_sym_dec_tagged_bb_0</value></param>
<param><key>cipher</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>packet_key_len</key><value>packet_len</value></param>
</block>
<block>
<key>crypto_sym_enc_tagged_bb</key>
<param><key>id</key><value>crypto_sym_enc_tagged_bb_0</value></param>
<param><key>cipher</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>key_len</key><value>"packet_len"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>max</key><value>127</value></param>
<param><key>min</key><value>-128</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmax</key><value>256</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>ncols</key><value>8*8</value></param>
<param><key>nrows</key><value>16*4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmax</key><value>256</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>ncols</key><value>8*8</value></param>
<param><key>nrows</key><value>16*4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0_1_0_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmax</key><value>256</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>name</key><value>"plain"</value></param>
<param><key>ncols</key><value>8*8</value></param>
<param><key>nrows</key><value>16*4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>update_time</key><value>0.00010</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0_1_0_1_0_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmax</key><value>256</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>name</key><value>"cipher"</value></param>
<param><key>ncols</key><value>8*8</value></param>
<param><key>nrows</key><value>16*4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>update_time</key><value>0.010</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0_0_1_0_1_0_1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>zmax</key><value>256</value></param>
<param><key>zmin</key><value>0</value></param>
<param><key>name</key><value>"decrypt"</value></param>
<param><key>ncols</key><value>8*8</value></param>
<param><key>nrows</key><value>16*4</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>update_time</key><value>0.00010</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>crypto_sym_enc_tagged_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_dec_tagged_bb_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_dec_tagged_bb_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_dec_tagged_bb_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0_1_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_tagged_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_tagged_bb_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_tagged_bb_0</source_block_id><sink_block_id>crypto_sym_dec_tagged_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_tagged_bb_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0_0_1_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
