<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.make_u8vector(17, 65)</value></param>
<param><key>period</key><value>500</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.string_to_symbol("iv")</value></param>
<param><key>period</key><value>1005</value></param>
</block>
<block>
<key>crypto_sym_ciph_desc</key>
<param><key>id</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>ciph_name</key><value>"aes-256-ctr"</value></param>
<param><key>keyfile</key><value>/home/maier/meinkey.bin</value></param>
<param><key>padding</key><value>False</value></param>
</block>
<block>
<key>crypto_sym_dec</key>
<param><key>id</key><value>crypto_sym_dec_0</value></param>
<param><key>ciph_desc</key><value>crypto_sym_ciph_desc_0</value></param>
</block>
<block>
<key>crypto_sym_enc</key>
<param><key>id</key><value>crypto_sym_enc_0</value></param>
<param><key>cipher</key><value>crypto_sym_ciph_desc_0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>crypto_sym_enc_0</sink_block_id><source_key>strobe</source_key><sink_key>plain</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_1</source_block_id><sink_block_id>crypto_sym_enc_0</sink_block_id><source_key>strobe</source_key><sink_key>plain</sink_key></connection>
<connection><source_block_id>crypto_sym_dec_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>decrypted</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_0</source_block_id><sink_block_id>crypto_sym_dec_0</sink_block_id><source_key>encrypted</source_key><sink_key>encrypted</sink_key></connection>
</flow_graph>
