<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>deletememessage</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.string_to_symbol("new_iv"),pmt.make_u8vector(16, 66))</value></param>
<param><key>period</key><value>3005</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.make_u8vector(16, 65)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_1</value></param>
<param><key>msg</key><value>pmt.string_to_symbol("new_iv")</value></param>
<param><key>period</key><value>3000</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>crypto_sym_ciph_desc</key>
<param><key>id</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>ciph_name</key><value>"aes-256-cbc"</value></param>
<param><key>keyfile</key><value>/home/maier/meinkey.bin</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>random_iv</key><value>True</value></param>
<param><key>start_iv</key><value>[]</value></param>
</block>
<block>
<key>crypto_sym_enc</key>
<param><key>id</key><value>crypto_sym_enc_0</value></param>
<param><key>cipher</key><value>crypto_sym_ciph_desc_0</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>crypto_sym_enc_0</sink_block_id><source_key>strobe</source_key><sink_key>plain</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>crypto_sym_enc_0</sink_block_id><source_key>strobe</source_key><sink_key>plain</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_1</source_block_id><sink_block_id>crypto_sym_enc_0</sink_block_id><source_key>strobe</source_key><sink_key>plain</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>encrypted</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>encrypted</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
