<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>key</value></param>
<param><key>value</key><value>crypto.key.make_rand_key(32)</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>affinity</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>affinity</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0</value></param>
<param><key>affinity</key><value>0</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>44</value></param>
<param><key>minsize</key><value>32</value></param>
</block>
<block>
<key>crypto_sym_ciph_desc</key>
<param><key>id</key><value>crypto_sym_ciph_desc_0</value></param>
<param><key>ciph_name</key><value>"aes-256-ofb"</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>key</key><value>key</value></param>
</block>
<block>
<key>crypto_sym_dec</key>
<param><key>id</key><value>crypto_sym_dec_0</value></param>
<param><key>ciph_desc</key><value>crypto_sym_ciph_desc_0</value></param>
</block>
<block>
<key>crypto_sym_enc</key>
<param><key>id</key><value>crypto_sym_enc_0</value></param>
<param><key>cipher</key><value>crypto_sym_ciph_desc_0</value></param>
</block>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>crypto_sym_enc_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>crypto_sym_dec_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>crypto_sym_enc_0</source_block_id><sink_block_id>crypto_sym_dec_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
